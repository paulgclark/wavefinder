<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_rate</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/paul/code/wavefinder/grc/weather_c434M_s200k.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/paul/code/wavefinder/grc/tmp_wave_finder_file.fft</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>x_start</key><value>-100</value></param>
<param><key>x_step</key><value>10</value></param>
<param><key>x_axis_label</key><value>"freq"</value></param>
<param><key>y_axis_label</key><value>"Power"</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>note</key><value>Frame Rate faster than signal</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>frame_rate</key><value>frame_rate</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
</block>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
